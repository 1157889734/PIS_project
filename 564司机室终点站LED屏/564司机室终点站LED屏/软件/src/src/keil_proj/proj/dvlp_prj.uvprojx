# Keil uVision project dvlp_prj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dvlp_prj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\src\porting_layer;..\src\driver\drv_bsp;..\src\driver\drv_CMIS;..\src\driver\drv_ether;..\src\driver\drv_lwip_v1.3.2\src\include;..\src\driver\drv_STM32F2xx_StdPeriph\inc;..\src\driver\drv_lwip_v1.3.2\port\STM32F2x7;..\src\driver\drv_lwip_v1.3.2\port\STM32F2x7\Standalone;..\src\driver\drv_lwip_v1.3.2\src\include\lwip;..\src\driver\drv_lwip_v1.3.2\src\include\netif;..\src\driver\drv_lwip_v1.3.2\src\include\ipv4;..\src\app;..\src\app\include;..\src\app\usr;..\src\app\process;..\src\driver\drv_IAP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group usr
    ../src/app/usr/: main.c
  group porting_layer
    ../src/porting_layer/: mem_str.c p_sys.c
  group drv_bsp
    ../src/driver/drv_bsp/: hc595.c MyApp.c MyAudio.c MyAudioSample.c MyBoard.c MyCommander.c MyEthernet.c MyFlash.c MyHttpd.c MyI2c.c MyI2s.c MyLwip.c MyMiscFunc.c MyNet.c MyProtocol.c MyStorage.c MySwitch.c MyTimer.c stm32f2xx_it.c bsp_dev_id.c
  group drv_CMIS
    ../src/driver/drv_CMIS/: core_cm3.c startup_stm32f2xx.s system_stm32f2xx.c
  group drv_ether
    ../src/driver/drv_ether/: stm32f2x7_eth.c
  group drv_lwip_v1.3.2
    ../src/driver/drv_lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../src/driver/drv_lwip_v1.3.2/src/core/: init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c
    ../src/driver/drv_lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../src/driver/drv_lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../src/driver/drv_lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group drv_STM32F2xx_StdPeriph
    ../src/driver/drv_STM32F2xx_StdPeriph/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_iwdg.c
  group process
    ../src/app/process/: process_led.c process_net.c process_ledscreen.c
  group drv_IAP
    ../src/driver/drv_IAP/: flash_if.c tftpserver.c tftp_cli.c iap_ram_func.c
software components: CMSIS:CORE 5.3.0

# Keil uVision project Stm207Test.uvproj, settings and files
target Stm207Test (ARM-ADS)
  device: STM32F207ZC STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ningbo_pis_app +hex
  AfterMake: D:\MDK4.22\ARM\BIN40\fromelf.exe --bin -o .\out\ningbo_pis_app.bin  .\out\ningbo_pis_app.axf
  c flags: Optim=1
  c include: .\mycode;.\library\inc;.\stm32f207core;.\eth_driver;.\lwip_v1.3.2\src\include\;.\lwip_v1.3.2\src\include\lwip;.\lwip_v1.3.2\src\include\netif;.\lwip_v1.3.2\src\include\ipv4;.\lwip_v1.3.2\port\STM32F2x7;.\lwip_v1.3.2\port\STM32F2x7\Standalone;.\drv_IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group library
    ./library/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group stm32f207core
    ./stm32f207core/: startup_stm32f2xx.s system_stm32f2xx.c core_cm3.c
  group eth_driver
    ./eth_driver/: stm32f2x7_eth.c
  group lwip
    ./lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lwip_v1.3.2/src/core/: init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c
    ./lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ./lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group mycode
    ./mycode/: hc595.c main.c MyApp.c MyAudioSample.c MyBoard.c MyCommander.c MyEthernet.c MyFlash.c MyI2c.c MyI2s.c MyMiscFunc.c MyNet.c MyProtocol.c MyStorage.c MySwitch.c MyTimer.c p_sys.c process_ledscreen.c Serial_bus.c stm32f2xx_it.c bsp_dev_id.c mem_str.c MyLwip.c MyHttpd.c MyAudio.c
  group iap_driver
    ./drv_IAP/: flash_if.c tftp_cli.c tftpserver.c

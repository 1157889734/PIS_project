# Keil uVision project PisAmp.uvprojx, settings and files
target PisAmp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PisAmp +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\mycode; .\device_driver;.\library\inc; .\stm32f207core; .\eth_driver; .\lwip_v1.3.2\src\include\; .\lwip_v1.3.2\src\include\lwip; .\lwip_v1.3.2\src\include\netif; .\lwip_v1.3.2\src\include\ipv4; .\lwip_v1.3.2\port\STM32F2x7; .\lwip_v1.3.2\port\STM32F2x7\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MyCode
    ./mycode/: main.c MyAdc.c MyApp.c MyAudio.c MyAudioSample.c MyBoard.c MyCommander.c MyEthernet.c MyFlash.c MyHttpd.c MyI2c.c MyI2s.c MyKey.c MyLwip.c MyMiscFunc.c MyNet.c MyNoise.c MyProtocol.c MyRamFunc.c MySelfTest.c MyStorage.c MySwitch.c MyTftpClient.c MyTimer.c stm32f2xx_it.c
  group lwip
    ./lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lwip_v1.3.2/src/core/: init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c
    ./lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ./lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group library
    ./library/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_adc.c stm32f2xx_wwdg.c
  group eth_driver
    ./eth_driver/: stm32f2x7_eth.c
  group device_driver
    ./device_driver/: soundcard.c
  group stm32f207core
    ./stm32f207core/: startup_stm32f2xx.s system_stm32f2xx.c core_cm3.c
software components: CMSIS:CORE 5.3.0

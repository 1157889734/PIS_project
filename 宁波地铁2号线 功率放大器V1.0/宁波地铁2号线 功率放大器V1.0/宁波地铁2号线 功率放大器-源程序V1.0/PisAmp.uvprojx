# Keil uVision project PisAmp.uvprojx, settings and files
target PisAmp (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: PisAmp +hex
  c flags: Optim=1
  c include: .\mycode; .\library\inc; .\stm32f207core; .\eth_driver; .\lwip_v1.3.2\src\include\; .\lwip_v1.3.2\src\include\lwip; .\lwip_v1.3.2\src\include\netif; .\lwip_v1.3.2\src\include\ipv4; .\lwip_v1.3.2\port\STM32F2x7; .\lwip_v1.3.2\port\STM32F2x7\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MyCode
    ./mycode/: main.c MyApp.c MyBoard.c MyMiscFunc.c MyNet.c MyEthernet.c stm32f2xx_it.c MyTimer.c MyLwip.c MyI2c.c MySwitch.c MyI2s.c MyAudioSample.c MyAudio.c MyProtocol.c MyHttpd.c MyFlash.c MyStorage.c MyCommander.c MyAdc.c MyKey.c MyNoise.c MySelfTest.c
  group library
    ./library/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_adc.c
  group stm32f207core
    ./stm32f207core/: startup_stm32f2xx.s system_stm32f2xx.c core_cm3.c
  group eth_driver
    ./eth_driver/: stm32f2x7_eth.c
  group lwip
    ./lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lwip_v1.3.2/src/core/: init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c
    ./lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ./lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
software components: CMSIS:CORE 5.3.0
